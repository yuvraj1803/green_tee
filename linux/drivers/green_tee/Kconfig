## linux/drivers/green_tee/Kconfig
```kconfig
config GREEN_TEE
    bool "Enable support for Green TEE (Trusted Execution Environment)"
```
